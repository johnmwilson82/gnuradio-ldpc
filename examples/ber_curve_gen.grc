<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_ldpc_decoder_def</key>
<param><key>id</key><value>dec_ldpc</value></param>
<param><key>file</key><value>gr.prefix() + '/share/gnuradio/examples/fec/271.127.3.112'</value></param>
<param><key>dim1</key><value>len(esno_0)</value></param>
<param><key>dim2</key><value>1</value></param>
<param><key>max_iter</key><value>50</value></param>
<param><key>ndim</key><value>2</value></param>
<param><key>sigma</key><value>0.5</value></param>
</block>
<block>
<key>variable_ldpc_encoder_def</key>
<param><key>id</key><value>enc_ldpc</value></param>
<param><key>file</key><value>gr.prefix() + '/share/gnuradio/examples/fec/271.127.3.112'</value></param>
<param><key>dim1</key><value>len(esno_0)</value></param>
<param><key>dim2</key><value>1</value></param>
<param><key>ndim</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>esno_0</value></param>
<param><key>value</key><value>numpy.arange(0, 8, .5) </value></param>
</block>
<block>
<key>variable_johns_ldpc_decoder_def</key>
<param><key>id</key><value>ldpc_dec</value></param>
<param><key>filename</key><value>'/home/john/git/gnuradio-ldpc/examples/408.pcmat'</value></param>
<param><key>dim1</key><value>16</value></param>
<param><key>dim2</key><value>1</value></param>
<param><key>num_iterations</key><value>50</value></param>
<param><key>message_length</key><value>204</value></param>
<param><key>ndim</key><value>2</value></param>
</block>
<block>
<key>variable_johns_ldpc_encoder_def</key>
<param><key>id</key><value>ldpc_enc</value></param>
<param><key>filename</key><value>'/home/john/git/gnuradio-ldpc/examples/408.pmat'</value></param>
<param><key>dim1</key><value>16</value></param>
<param><key>dim2</key><value>1</value></param>
<param><key>ndim</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>fec_bercurve_generator</key>
<param><key>id</key><value>fec_bercurve_generator_0</value></param>
<param><key>decoder_list</key><value>ldpc_dec</value></param>
<param><key>encoder_list</key><value>ldpc_enc</value></param>
<param><key>esno</key><value>esno_0</value></param>
<param><key>puncpat</key><value>'11'</value></param>
<param><key>samp_rate</key><value>35000000</value></param>
<bus_source>1</bus_source>
</block>
<block>
<key>fec_bercurve_generator</key>
<param><key>id</key><value>fec_bercurve_generator_1</value></param>
<param><key>decoder_list</key><value>dec_ldpc</value></param>
<param><key>encoder_list</key><value>enc_ldpc</value></param>
<param><key>esno</key><value>esno_0</value></param>
<param><key>puncpat</key><value>'11'</value></param>
<param><key>samp_rate</key><value>35000000</value></param>
<bus_source>1</bus_source>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import ldpc</value></param>
</block>
<block>
<key>qtgui_bercurve_sink</key>
<param><key>id</key><value>qtgui_bercurve_sink_0</value></param>
<param><key>berlimit</key><value>-6.0</value></param>
<param><key>berminerrors</key><value>500</value></param>
<param><key>num_curves</key><value>2</value></param>
<param><key>ymin</key><value>-6</value></param>
<param><key>esno</key><value>esno_0</value></param>
<bus_sink>1</bus_sink>
</block>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>32</source_key><sink_key>64</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>10</source_key><sink_key>10</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>11</source_key><sink_key>11</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>12</source_key><sink_key>12</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>13</source_key><sink_key>13</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>14</source_key><sink_key>14</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>15</source_key><sink_key>15</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>16</source_key><sink_key>16</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>17</source_key><sink_key>17</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>18</source_key><sink_key>18</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>19</source_key><sink_key>19</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>20</source_key><sink_key>20</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>21</source_key><sink_key>21</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>22</source_key><sink_key>22</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>23</source_key><sink_key>23</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>24</source_key><sink_key>24</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>25</source_key><sink_key>25</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>26</source_key><sink_key>26</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>27</source_key><sink_key>27</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>28</source_key><sink_key>28</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>29</source_key><sink_key>29</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>30</source_key><sink_key>30</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>31</source_key><sink_key>31</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>4</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>5</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>6</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>7</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>8</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>9</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>32</source_key><sink_key>65</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>0</source_key><sink_key>32</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>1</source_key><sink_key>33</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>10</source_key><sink_key>42</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>11</source_key><sink_key>43</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>12</source_key><sink_key>44</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>13</source_key><sink_key>45</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>14</source_key><sink_key>46</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>15</source_key><sink_key>47</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>16</source_key><sink_key>48</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>17</source_key><sink_key>49</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>18</source_key><sink_key>50</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>19</source_key><sink_key>51</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>2</source_key><sink_key>34</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>20</source_key><sink_key>52</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>21</source_key><sink_key>53</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>22</source_key><sink_key>54</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>23</source_key><sink_key>55</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>24</source_key><sink_key>56</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>25</source_key><sink_key>57</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>26</source_key><sink_key>58</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>27</source_key><sink_key>59</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>28</source_key><sink_key>60</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>29</source_key><sink_key>61</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>3</source_key><sink_key>35</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>30</source_key><sink_key>62</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>31</source_key><sink_key>63</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>4</source_key><sink_key>36</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>5</source_key><sink_key>37</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>6</source_key><sink_key>38</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>7</source_key><sink_key>39</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>8</source_key><sink_key>40</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_1</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>9</source_key><sink_key>41</sink_key></connection>
</flow_graph>
